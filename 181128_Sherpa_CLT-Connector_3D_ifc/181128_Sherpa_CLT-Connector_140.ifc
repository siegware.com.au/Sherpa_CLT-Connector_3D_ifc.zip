Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:32:02
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 181128_SHERPA_CLT-Connector_140
Description: 181128_SHERPA_CLT-Connector_140

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 181128_SHERPA_CLT-Connector_140
Type - PredefinedType: USERDEFINED
Description: CLT-Connector 8x140
SHERPA Connection Systems GmbH - Art.-Nr.: 10000029071; Aluminium: EN AW - 6082; Type: CLT-Connector 8x140; 6.5x65mm: 10000023616; Number_of_Screws_6.5x65mm: 2; 8x140mm: 8; Number_of_Screws_8x140mm: 10000032979; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
