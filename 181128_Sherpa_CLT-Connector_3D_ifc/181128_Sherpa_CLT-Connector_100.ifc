Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T10:31:06
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 181128_SHERPA_CLT-Connector_100
Description: 181128_SHERPA_CLT-Connector_100

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 181128_SHERPA_CLT-Connector_100
Type - PredefinedType: USERDEFINED
Description: CLT-Connector 8x100
SHERPA Connection Systems GmbH - Art.-Nr.: 10000029071; Aluminium: EN AW - 6082; Type: CLT-Connector 8x100; 6.5x65mm: 10000023616; Number_of_Screws_8x100m: 8; Number_of_Screws_6.5x65mm: 2; 8x100mm: 10000023937; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
